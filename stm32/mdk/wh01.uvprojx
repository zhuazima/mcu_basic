# Keil uVision project wh01.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wh01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\user;..\Libraries\CMSIS\CM3\CoreSupport;..\hal;..\os;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\app;..\mcu_sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Libraries
    ../user/: system_stm32f10x.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../startup/: startup_stm32f10x_md.s
  group user
    ../user/: stm32f10x_it.c main.c
  group hal
    ../hal/: hal_led.c hal_cpu.c hal_time.c hal_key.c hal_oled.c hal_Uart.c hal_rfd.c hal_eeprom.c hal_beep.c
  group os
    ../os/: OS_System.c
  group app
    ../app/: app.c para.c
  group mcu_sdk
    ../mcu_sdk/: cJSON.c mcu_api.c protocol.c system.c
